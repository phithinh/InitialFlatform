# IAR project Project.ewp, settings and files
configuration Board (ARM)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_MD; USE_STDPERIPH_DRIVER; HSE_VALUE=8000000
  ICCARM.CCDiagSuppress: Pa050,Pe161
  ICCARM.CCIncludePath2: ..\..\includes
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\Workspace\InitialFlatform\project\includes
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: MainBoard.out
  ILINK.IlinkIcfFile: icfFile\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group appls/inverter
    ../../../scrs/appls/inverter/: inverter_adpts.h inverter_main.c inverter_main.h
  group appls/inverter/inv_com
    ../../../scrs/appls/inverter/inv_com/: inv_com.c inv_com.h
  group appls/inverter/inv_ctr
    ../../../scrs/appls/inverter/inv_ctr/: inverter_controller.c inverter_controller_adapts.h inverter_controller_cfg.h inverter_controller_pri.h inverter_controller_pub.h
  group appls/net
    ../../../scrs/appls/net/: net.c net.h net_adpts.h
  group hwal/boardAL/ADC-DMA
    ../../../scrs/hwal/boardAL/ADC_DMA/: ADC_DMA.c ADC_DMA.h
  group hwal/boardAL/FlashRW
    ../../../scrs/hwal/boardAL/FlashRW/: FlashRW.c FlashRW.h MemoryMap.h
  group hwal/boardAL/serial_com
    ../../../scrs/hwal/boardAL/serial_com/RS485/: RS485.c RS485.h
    ../../../scrs/hwal/boardAL/serial_com/: serial_cbk.h serial_com.h
  group hwal/boardAL/SVPWM
    ../../../scrs/hwal/boardAL/SVPWM/: SVPWM.c SVPWM.h
  group hwal/Common
    ../../../scrs/hwal/Common/: compiler.h general_define.h integer.h PlatFormType.h
  group hwal/McuDrv/gpio
    ../../../scrs/hwal/McuDrv/gpio/: gpio_common.c gpio_common.h gpio_hardware_config.h gpio_pub.h
  group hwal/McuDrv/gpio/digital_in
    ../../../scrs/hwal/McuDrv/gpio/digital_in/: digital_in.c digital_in_pub.h
  group hwal/McuDrv/gpio/digital_out
    ../../../scrs/hwal/McuDrv/gpio/digital_out/: digital_out.c digital_out_pri.h digital_out_pub.h
  group hwal/McuDrv/startup
    ../../../scrs/hwal/McuDrv/startup/: main.c startup_stm32f10x_md_frertos_iar.s system_stm32f10x.c
  group hwal/McuDrv/uart
    ../../../scrs/hwal/McuDrv/uart/: uart.c uart_cfg.c uart_cfg.h uart_IRQ.c uart_pub.h
  group hwal/services/OS
    ../../../scrs/hwal/services/OS/: FreeRTOSConfig.h heap_2.c OS.c OS.h OS_Layer.h port.c portasm.s portmacro.h
  group libs
    ../../../scrs/libs/: stm32f10x_conf.h
  group libs/_FreeRTOS
    ../../../scrs/libs/_FreeRTOS/: list.c tasks.c timers.c
  group libs/_FreeRTOS/include
    ../../../scrs/libs/_FreeRTOS/include/: croutine.h event_groups.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group libs/CMSIS/CM3/CoreSupport
    ../../../scrs/libs/CMSIS/CM3/CoreSupport/: core_cm3.h
  group libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x
    ../../../scrs/libs/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h
  group libs/STM32F10x_StdPeriph_Driver/inc
    ../../../scrs/libs/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group libs/STM32F10x_StdPeriph_Driver/src
    ../../../scrs/libs/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group rte/environment
    ../../../scrs/rte/environment/: environment.c environment.h
  group rte/interfaces
    ../../../scrs/rte/interfaces/: interfaces.c interfaces.h p_com_tx.h
  group rte/scheduler
    ../../../scrs/rte/scheduler/: stm32f10x_it.c stm32f10x_it.h
